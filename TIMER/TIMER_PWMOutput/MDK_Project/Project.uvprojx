# Keil uVision project Project.uvprojx, settings and files
target Project (6150000::V6.15::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: FOC_CURRENT +hex
  AfterMake: fromelf.exe --bin --output ./Out_Files/Project.bin ./Objects/Project.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\Core_Drivers\CMSIS;..\Core_Drivers\Device;..\Core_Drivers\Device\other;..\Core_Drivers\HAL_Driver;..\Core_Drivers\HAL_Driver\Src;..\Core_Drivers\HAL_Driver\Inc;..\Source_Code\APP;..\Source_Code\BSP_Driver;..\Source_Code\IC_Driver;..\..\..\Core_Drivers\CMSIS;..\..\..\Core_Drivers\Device;..\..\..\Core_Drivers\HAL_Driver\Inc;..\..\..\MATLAB
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x20000 size 0x400
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group CoreDriver/CMSIS
    ../../../Core_Drivers/CMSIS/: core_cm33.h arm_ARMv8MMLldfsp_math.lib
  group CoreDriver/Device
    ../../../Core_Drivers/Device/: Startup_ACM32F4.s System_ACM32F4.c System_Accelerate.lib
  group CoreDriver/HAL
    ../../../Core_Drivers/HAL_Driver/Src/: HAL_DMA.c HAL_GPIO.c HAL_Uart.c HAL_TIMER.c HAL_EFlash.c HAL_EFlash_EX.lib HAL_TIMER_EX.c HAL_ADC.c HAL_FAU_20210325.lib
  group SourceCode/APP
    ../Source_Code/APP/: app.c bsp_advance_tim.c bsp_adc.c
  group SourceCode/main
    ../Source_Code/: main.c
  group MATLAB
    ../../../MATLAB/: FOC_CURRENT.lib
